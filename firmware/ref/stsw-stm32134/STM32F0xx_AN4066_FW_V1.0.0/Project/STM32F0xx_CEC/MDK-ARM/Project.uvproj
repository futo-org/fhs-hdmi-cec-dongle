# Keil uVision project Project.uvproj, settings and files
target STM320518-EVAL (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM320518-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0XX, USE_STM320518_EVAL
  c include: ..\inc;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM320518_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../src/: cec_display.c stm32f0xx_it.c main.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_cec.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_i2c.c stm32f0xx_spi.c stm32f0xx_dbgmcu.c
  group CMSIS
    ../../../Libraries/CMSIS//Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM320518_EVAL/: stm320518_eval.c stm320518_eval_lcd.c stm320518_eval_cec.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group Doc
    ../: readme.txt
